# IAR project LiPo_V7M.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x40
  General.SCRStackSize: 32
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: tiny85 ATtiny85
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgtiny85.xcl
configuration Debug (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _PROTEUS_
  ICCAVR.CCOptLevel: 0
  group (top)
    Src/: hard.c key.c main.c misc.c
